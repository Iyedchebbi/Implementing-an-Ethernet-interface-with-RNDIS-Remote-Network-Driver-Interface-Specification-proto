<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\1212.ewp</path>
  </project>
  <batchBuild />
</workspace>
